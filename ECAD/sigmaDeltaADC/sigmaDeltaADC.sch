File: ECAD/sigmaDeltaADC/sigmaDeltaADC.sch (KiCad schematic (older format))
At the start: 31 parts

Commit message: Numbered componets
Parts:
- gave numbers to parts that had none: 31
